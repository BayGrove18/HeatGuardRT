# Keil uVision project project.uvprojx, settings and files
target liu (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\BSP\BEEP;..\BSP\DHT11;..\BSP\DMA;..\BSP\EXTI;..\BSP\IAP;..\BSP\KEY;..\BSP\LCD;..\BSP\LED;..\BSP\SPI;..\BSP\STMFLASH;..\BSP\TIMER;..\BSP\microwave
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: boot_handoff.c actuator.c control.c crc32.c diagnostics.c handoff_contract.c main.c spi_bus.c supervisor.c upgrade.c upgrade_transport.c w25q64.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/DHT11/: dht11.c
    ../BSP/BEEP/: beep.c
    ../BSP/EXTI/: exti.c
    ../BSP/LCD/: GUI.c lcd.c
    ../BSP/LED/: led.c
    ../BSP/SPI/: SPI.c
    ../BSP/TIMER/: timer.c
  group SYSTEM
    ../STM32F10x_FWLib/src/: stm32f10x_bkp.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS_Core
    ../FreeRTOS/: list.c queue.c tasks.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
